<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ar</value></param>
<param><key>value</key><value>0.</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Audio_Gain</value></param>
<param><key>value</key><value>1.</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Volumen</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>4./100.</value></param>
<param><key>stop</key><value>4</value></param>
<param><key>widget</key><value>dial</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B</value></param>
<param><key>value</key><value>220e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BW</value></param>
<param><key>value</key><value>B/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BWaudio</value></param>
<param><key>value</key><value>5.5e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>D</value></param>
<param><key>value</key><value>Kf*V_pmi/BWaudio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DF</value></param>
<param><key>value</key><value>BW-BWaudio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kf</value></param>
<param><key>value</key><value>DF/V_pmi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>V_pmi</value></param>
<param><key>value</key><value>1.</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>390625</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>value</key><value>BWaudio*2</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>int(samp_rate_audio)</value></param>
</block>
<block>
<key>b_Canal_AWGN</key>
<param><key>id</key><value>b_Canal_AWGN_0</value></param>
<param><key>BW</key><value>samp_rate/2</value></param>
<param><key>Ch_NodB</key><value>-140</value></param>
<param><key>Ch_Toffset</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>b_PSD_c</key>
<param><key>id</key><value>b_PSD_c_0</value></param>
<param><key>Fc</key><value>0</value></param>
<param><key>samp_rate_audio</key><value>samp_rate</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>"PSD"</value></param>
<param><key>Ymax</key><value>6e-6</value></param>
</block>
<block>
<key>b_discriminador_frec_umd_cf</key>
<param><key>id</key><value>b_discriminador_frec_umd_cf_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_0_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value>2*math.pi*Kf</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0_0</value></param>
<param><key>file</key><value>/media/uis-e3t/DATADRIVE1/MisGitHub/pruebas_gnuradio/bush-clinton_debate_waffle.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(samp_rate_audio)</value></param>
<param><key>interp</key><value>samp_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>int(samp_rate)</value></param>
<param><key>interp</key><value>int(samp_rate_audio)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs</value></param>
<param><key>stream_id</key><value>T1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs_0</value></param>
<param><key>stream_id</key><value>T3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs_0_0</value></param>
<param><key>stream_id</key><value>R3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso</value></param>
<param><key>stream_id</key><value>T1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso_0</value></param>
<param><key>stream_id</key><value>T3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso_0_0</value></param>
<param><key>stream_id</key><value>R3</value></param>
</block>
<connection><source_block_id>b_Canal_AWGN_0</source_block_id><sink_block_id>b_discriminador_frec_umd_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_discriminador_frec_umd_cf_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>vs_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_0_0</source_block_id><sink_block_id>b_discriminador_frec_umd_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_0_0</source_block_id><sink_block_id>vs</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0_0</source_block_id><sink_block_id>vs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_vco_c_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso</source_block_id><sink_block_id>b_PSD_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
