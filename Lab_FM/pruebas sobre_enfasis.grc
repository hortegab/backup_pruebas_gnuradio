<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ar</value></param>
<param><key>value</key><value>0.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B</value></param>
<param><key>value</key><value>220e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BW</value></param>
<param><key>value</key><value>B/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BWaudio</value></param>
<param><key>value</key><value>5.5e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>D</value></param>
<param><key>value</key><value>Kf*V_pmi/BWaudio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DF</value></param>
<param><key>value</key><value>BW-BWaudio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kf</value></param>
<param><key>value</key><value>DF/V_pmi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>V_pmi</value></param>
<param><key>value</key><value>1.</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>390625</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>value</key><value>BWaudio*2</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_preemph</key>
<param><key>id</key><value>analog_fm_preemph_0</value></param>
<param><key>fh</key><value>-1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_preemph</key>
<param><key>id</key><value>analog_fm_preemph_0_0</value></param>
<param><key>fh</key><value>-1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>b_PSD</key>
<param><key>id</key><value>b_PSD_0</value></param>
<param><key>samp_rate_audio</key><value>samp_rate_audio</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>'pre-enfasis'</value></param>
<param><key>Ymax</key><value>0.00015</value></param>
</block>
<block>
<key>b_PSD</key>
<param><key>id</key><value>b_PSD_0_0</value></param>
<param><key>samp_rate_audio</key><value>samp_rate_audio</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>'de-enfasis'</value></param>
<param><key>Ymax</key><value>0.00015</value></param>
</block>
<block>
<key>b_PSD</key>
<param><key>id</key><value>b_PSD_0_0_0</value></param>
<param><key>samp_rate_audio</key><value>samp_rate_audio</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>'enfasis-de-enfasis'</value></param>
<param><key>Ymax</key><value>0.00015</value></param>
</block>
<block>
<key>b_PSD</key>
<param><key>id</key><value>b_PSD_0_1</value></param>
<param><key>samp_rate_audio</key><value>samp_rate_audio</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>'ruido'</value></param>
<param><key>Ymax</key><value>0.00015</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<connection><source_block_id>analog_fm_deemph_0</source_block_id><sink_block_id>b_PSD_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_deemph_0_0</source_block_id><sink_block_id>b_PSD_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_preemph_0</source_block_id><sink_block_id>b_PSD_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_preemph_0_0</source_block_id><sink_block_id>analog_fm_deemph_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>analog_fm_deemph_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>analog_fm_preemph_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>analog_fm_preemph_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>b_PSD_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
