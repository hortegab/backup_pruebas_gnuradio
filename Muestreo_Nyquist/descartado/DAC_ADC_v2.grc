<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ap</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Del</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Retardo</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>20000/1000</value></param>
<param><key>stop</key><value>20000</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Vol</value></param>
<param><key>value</key><value>1.</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Volumen</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>10/100.</value></param>
<param><key>stop</key><value>10.</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>22000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>value</key><value>11000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>file</key><value>/home/uis-e3t/MisGits/comdig_multimedia/bush-clinton_debate_waffle_plus.wav</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0_0</value></param>
<param><key>file</key><value>/home/uis-e3t/MisGits/comdig_multimedia/bush-clinton_debate_waffle.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>menu</value></param>
<param><key>gui_hint</key><value>1,0,1,3</value></param>
<param><key>label0</key><value>tiempo</value></param>
<param><key>label1</key><value>frecuencia</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>blocks_wavfile_source_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
