options:
  parameters:
    author: homero
    generate_options: qt_gui
    id: sistemabase
    output_language: python
    title: sistemabase
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: Dtiming
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Dtiming
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: '7'
  states: {}
- name: Nlob_n
  id: variable
  parameters:
    value: '6'
  states: {}
- name: Noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Noise
    start: '0'
    step: '0.1'
    stop: '4'
    value: '0.2'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Retardo_bits
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay transmited signal to match with the received signal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*10
    value: '0'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: h0
  id: variable
  parameters:
    value: ([1]*Sps)
  states: {}
- name: h1
  id: variable
  parameters:
    value: mis_funciones.rcos(Sps,ntaps,alpha)
  states: {}
- name: h2
  id: variable
  parameters:
    value: mis_funciones.rrcos(Sps,ntaps,alpha)
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: Nlob_n*Sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: samp_rate_dac
  id: variable
  parameters:
    value: samp_rate*32
  states: {}
- name: E3TRadio_bipolar_decisor_ff_0
  id: E3TRadio_bipolar_decisor_ff
  parameters: {}
  states: {}
- name: E3TRadio_diezma_ff_0
  id: E3TRadio_diezma_ff
  parameters:
    M: Dtiming
    N: Sps
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,1
    label0: T1 R1
    label1: T2 R2
    label2: T3 R3
    label3: Eye Diagramm
    label4: Timing
    num_tabs: '5'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: Noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: b_EYE_Timing_f_0
  id: b_EYE_Timing_f
  parameters:
    AlphaLineas: '0.5'
    Delay: '0'
    GrosorLineas: '20'
    N_eyes: '2'
    Retardo_Timing: Dtiming
    Samprate: samp_rate
    Sps: Sps
    Title: '"Eye Diagram and Timing"'
    Ymax: '2'
    Ymin: '-2'
    gui_hint: Menu@4:1,0,1,1
  states: {}
- name: b_PSD_f_0
  id: b_PSD_f
  parameters:
    Ensayos: '1000000'
    N: '1024'
    Titulo: '''espectro'''
    Ymax: '4e-6'
    gui_hint: Menu@1:1,0,1,1
    samp_rate: samp_rate
  states: {}
- name: b_bipolar_to_unipolar_ff_0
  id: b_bipolar_to_unipolar_ff
  parameters: {}
  states: {}
- name: b_eye_diagram_f_0
  id: b_eye_diagram_f
  parameters:
    Delay: int(Sps/2)
    Sps: Sps
    samp_rate: samp_rate
  states: {state: disabled}
- name: b_unipolar2bipolar_ff_0
  id: b_unipolar2bipolar_ff
  parameters: {}
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: Retardo_bits
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/radiogis_director/MisGits/comdiguis_b1a_2021si/Fase I/received
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/radiogis_director/MisGits/comdiguispractices2021si.3.8/unit I/Pract1.basic system based in rectangular pulse form/enviado.jpg
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/Sps
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h0
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: h0
    type: fff
  states: {}
- name: mis_funciones
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport numpy as np\nimport math\n\ndef nyq(Sps,ntaps):\n    k=np.linspace(-ntaps/2, ntaps/2-1, ntaps)\n    h=np.sinc(k/Sps)\n    return h\n    \n#######################################################\n##                  Delta                            ##\n#######################################################                       \ndef delta(ntaps):\n    cerosd=(   [0]*(int(ntaps/2)-1)    )\n    cerosdi=(   [0]*(int(ntaps/2))     )\n    delta_i= np.concatenate(( cerosdi, ([1]) ))\n    delta=np.concatenate(( delta_i, cerosd ))\n    return delta\n   \n#######################################################\n##               Forma Coseno Alzado                 ##\n#######################################################                       \ndef rcos(Sps,ntaps,beta):\n    if beta==0:\n        h=nyq(Sps,ntaps)\n    else:\n        h=ntaps*[0,]\n        for n in range(ntaps):\n            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector\n            if abs(k)==Sps/(2.*beta):\n                h[n]=np.sinc(1./(2.*beta))*math.pi/4.\n            else:\n                h[n]=np.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                \n    Amp=np.amax(h)\n    return h/Amp\n    \n#######################################################\n##            Forma Raiz de Coseno Alzado            ##\n#######################################################                       \n\ndef rrcos(Sps,ntaps,beta):\n    if beta==0:\n        h=nyq(Sps,ntaps)\n    else:\n        h=ntaps*[0,]\n        beta4=4.*beta\n        for n in range(ntaps):\n            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector\n            if k==0:\n                h[n]=1+beta*(4./math.pi-1.)\n            elif abs(k)==Sps/beta4:\n                ha=(1.+2./math.pi)*math.sin(math.pi/beta4)\n                hb=(1.-2./math.pi)*math.cos(math.pi/beta4)\n                h[n]=(ha+hb)*beta/math.sqrt(2.)\n            else:\n                ks=k/Sps\n                kspi=math.pi*ks\n                Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))\n                Den=kspi*(1.-(beta4*ks)**2)\n                h[n]=Num/Den                \n    Amp=np.amax(h)\n    return h/Amp\n\n"
  states: {}
- name: note_0
  id: note
  parameters:
    note: CAPA PRE-CANAL
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: CAPA CANAL
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Mensaje
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: PCM
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: Menu@3:0,0,1,1
    label1: R2
    label2: R2.0
    nconnections: '2'
    samp_per_symbol: Sps
    size: '1024'
    srate: samp_rate
    type: float
    width1: '4'
    width2: '4'
    ymax: '6'
    ymin: '-6'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: Menu@1:1,0,1,1
    label1: T2
    label2: R2
    name: '"Espectro en dB"'
    nconnections: '2'
    type: float
    width1: '3'
    width2: '3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@0:0,0,1,1
    label1: T1
    label2: R1
    marker1: '0'
    marker2: '7'
    nconnections: '3'
    size: ntaps
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '2'
    width2: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:0,0,1,1
    label1: T2
    label2: R2
    nconnections: '2'
    size: ntaps
    srate: samp_rate
    type: float
    width1: '2'
    width2: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: T1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: T2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: T0
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R0
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R-1
  states: {}
- name: virtual_sink_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: T-1
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R2
  states: {}
- name: virtual_sink_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: R2.0
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: R1.0
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: R1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: T1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: T2
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: R2
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: R2.0
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: R1
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: R1.0
  states: {}

connections:
- [E3TRadio_bipolar_decisor_ff_0, '0', b_bipolar_to_unipolar_ff_0, '0']
- [E3TRadio_bipolar_decisor_ff_0, '0', virtual_sink_0_1_0, '0']
- [E3TRadio_diezma_ff_0, '0', E3TRadio_bipolar_decisor_ff_0, '0']
- [E3TRadio_diezma_ff_0, '0', virtual_sink_0_1, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [b_bipolar_to_unipolar_ff_0, '0', blocks_float_to_char_0, '0']
- [b_unipolar2bipolar_ff_0, '0', interp_fir_filter_xxx_0, '0']
- [b_unipolar2bipolar_ff_0, '0', virtual_sink_0, '0']
- [blocks_add_xx_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0_1, '0']
- [blocks_char_to_float_1, '0', b_unipolar2bipolar_ff_0, '0']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0_0_0_1, '0']
- [blocks_float_to_char_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_float_to_char_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', E3TRadio_diezma_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_0_1_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_0_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_add_xx_0, '1']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_delay_1, '0']
- [virtual_source_0_0, '0', b_PSD_f_0, '0']
- [virtual_source_0_0, '0', b_eye_diagram_f_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_0_1, '0', qtgui_eye_sink_x_0, '0']
- [virtual_source_0_0_1, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_0_1, '0', qtgui_time_sink_x_0_0, '1']
- [virtual_source_0_0_1_0, '0', b_EYE_Timing_f_0, '0']
- [virtual_source_0_0_1_0, '0', qtgui_eye_sink_x_0, '1']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_0_1_0, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
