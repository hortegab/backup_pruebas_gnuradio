options:
  parameters:
    author: homero
    generate_options: qt_gui
    id: sistemabase
    output_language: python
    title: sistemabase
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: Dtiming
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Dtiming
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: '7'
  states: {}
- name: M
  id: variable
  parameters:
    value: len(tabla_verdad)
  states: {}
- name: Nlob_n
  id: variable
  parameters:
    value: '6'
  states: {}
- name: Noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Noise
    start: '0'
    step: '0.1'
    stop: '4'
    value: '0'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Retardo_bits
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay transmited signal to match with the received signal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*10
    value: '0'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/bps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: bps
  id: variable
  parameters:
    value: math.log(M,2)
  states: {}
- name: h0
  id: variable
  parameters:
    value: ([1]*Sps)
  states: {}
- name: h1
  id: variable
  parameters:
    value: mis_funciones.rcos(Sps,ntaps,alpha)
  states: {}
- name: h2
  id: variable
  parameters:
    value: mis_funciones.rrcos(Sps,ntaps,alpha)
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: Nlob_n*Sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: samp_rate_dac
  id: variable
  parameters:
    value: samp_rate*32
  states: {}
- name: tabla_verdad
  id: variable
  parameters:
    value: (1+1j, -1+1j, -1-1j, 1-1j)
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,1
    label0: T1 R1
    label1: T2 R2
    label2: T3 R3
    label3: T4r
    label4: T4-R4
    num_tabs: '5'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.2'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000000'
    repeat: 'True'
    type: byte
  states: {}
- name: b_demod_constelacion_cb_0
  id: b_demod_constelacion_cb
  parameters:
    Constelacion: tabla_verdad
  states: {}
- name: b_mod_constelacion_cb_0
  id: b_mod_constelacion_cb
  parameters:
    Constelacion: tabla_verdad
  states: {}
- name: b_u_M_PAM_bb_0
  id: b_u_M_PAM_bb
  parameters:
    M: M
  states: {}
- name: b_u_de_M_PAM_bb_0
  id: b_u_de_M_PAM_bb
  parameters:
    M: '4'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: Retardo_bits
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: mis_funciones
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport numpy as np\nimport math\n\ndef nyq(Sps,ntaps):\n    k=np.linspace(-ntaps/2, ntaps/2-1, ntaps)\n    h=np.sinc(k/Sps)\n    return h\n    \n#######################################################\n##                  Delta                            ##\n#######################################################                       \ndef delta(ntaps):\n    cerosd=(   [0]*(int(ntaps/2)-1)    )\n    cerosdi=(   [0]*(int(ntaps/2))     )\n    delta_i= np.concatenate(( cerosdi, ([1]) ))\n    delta=np.concatenate(( delta_i, cerosd ))\n    return delta\n   \n#######################################################\n##               Forma Coseno Alzado                 ##\n#######################################################                       \ndef rcos(Sps,ntaps,beta):\n    if beta==0:\n        h=nyq(Sps,ntaps)\n    else:\n        h=ntaps*[0,]\n        for n in range(ntaps):\n            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector\n            if abs(k)==Sps/(2.*beta):\n                h[n]=np.sinc(1./(2.*beta))*math.pi/4.\n            else:\n                h[n]=np.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                \n    Amp=np.amax(h)\n    return h/Amp\n    \n#######################################################\n##            Forma Raiz de Coseno Alzado            ##\n#######################################################                       \n\ndef rrcos(Sps,ntaps,beta):\n    if beta==0:\n        h=nyq(Sps,ntaps)\n    else:\n        h=ntaps*[0,]\n        beta4=4.*beta\n        for n in range(ntaps):\n            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector\n            if k==0:\n                h[n]=1+beta*(4./math.pi-1.)\n            elif abs(k)==Sps/beta4:\n                ha=(1.+2./math.pi)*math.sin(math.pi/beta4)\n                hb=(1.-2./math.pi)*math.cos(math.pi/beta4)\n                h[n]=(ha+hb)*beta/math.sqrt(2.)\n            else:\n                ks=k/Sps\n                kspi=math.pi*ks\n                Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))\n                Den=kspi*(1.-(beta4*ks)**2)\n                h[n]=Num/Den                \n    Amp=np.amax(h)\n    return h/Amp\n\n"
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Menu@2:2,0,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Menu@2:2,1,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Menu@3:1,0,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@0:0,0,1,1
    label1: T1
    label2: R1
    marker1: '0'
    marker2: '7'
    name: '"Info binaria"'
    nconnections: '2'
    size: ntaps
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '2'
    width2: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:0,0,1,1
    label1: T1
    marker1: '0'
    size: int(32/bps)
    srate: Rs
    stemplot: 'True'
    type: float
    width1: '2'
    ymax: M+1
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@2:0,0,1,2
    label1: I signal
    label2: Q signal
    name: '"Tx"'
    size: int(32/bps)
    srate: Rs
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@3:0,0,1,2
    size: int(Sps*32/bps)
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@2:1,0,1,2
    label1: I signal
    label2: Q signal
    name: '"Rx"'
    size: int(32/bps)
    srate: Rs
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: T1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: T2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: T3
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R3
  states: {}
- name: virtual_sink_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: T4r
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R2
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: R1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: T1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: T2
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: T3
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: T4r
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: R3
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: R1
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', virtual_sink_0_0_0_1, '0']
- [analog_random_source_x_0, '0', b_u_M_PAM_bb_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0, '0']
- [b_demod_constelacion_cb_0, '0', b_u_de_M_PAM_bb_0, '0']
- [b_demod_constelacion_cb_0, '0', virtual_sink_0_0_1, '0']
- [b_mod_constelacion_cb_0, '0', blocks_add_xx_0, '1']
- [b_mod_constelacion_cb_0, '0', virtual_sink_0_0_0, '0']
- [b_u_M_PAM_bb_0, '0', b_mod_constelacion_cb_0, '0']
- [b_u_M_PAM_bb_0, '0', virtual_sink_0_0, '0']
- [b_u_de_M_PAM_bb_0, '0', blocks_null_sink_0, '0']
- [b_u_de_M_PAM_bb_0, '0', virtual_sink_0_1_0, '0']
- [blocks_add_xx_0, '0', b_demod_constelacion_cb_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_delay_1, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', blocks_char_to_float_0, '0']
- [virtual_source_0_0, '0', blocks_char_to_float_0_1, '0']
- [virtual_source_0_0_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_0_0, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_0_0_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [virtual_source_0_0_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [virtual_source_0_0_0_1, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_0_0_0_1, '0', qtgui_time_sink_x_1_1, '0']
- [virtual_source_0_1, '0', blocks_char_to_float_0_0, '0']

metadata:
  file_format: 1
