options:
  parameters:
    author: DANIEL CARCHI
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: MODULADOR DQPSK
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: W*(1+Rolloff)
  states: {}
- name: BW_rect
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: BpS
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: M
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs/BpS
  states: {}
- name: Retardo_Timing
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@0:0,0,1,1
    label: Timing
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: '0'
    widget: counter
  states: {}
- name: Retardo_bits
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@4:0,0,1,1
    label: Delay transmited signal to match with the received signal
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*10
    value: '0'
  states: {}
- name: Rolloff
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: W
  id: variable
  parameters:
    value: Rb/2
  states: {}
- name: coef_rx
  id: variable
  parameters:
    value: 2**8
  states: {}
- name: constelacion
  id: variable
  parameters:
    value: digital.psk_constellation(M,no_code,False)
  states: {}
- name: h
  id: variable
  parameters:
    value: wform.rrcos(Sps,ntaps,Rolloff)
  states: {state: disabled}
- name: h
  id: variable
  parameters:
    value: wform.rect(Sps)
  states: {}
- name: no_code
  id: variable
  parameters:
    value: digital.utils.mod_codes.NO_CODE
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: Sps*16
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(samp_rate_2920_rx/coef_rx)
  states: {}
- name: samp_rate_2920_rx
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: b_Eye_Diagram_simple_c_0
  id: b_Eye_Diagram_simple_c
  parameters:
    AlphaLineas: '0.5'
    Delay_i: '0'
    GrosorLineas: '20'
    Kint: '1'
    N_eyes: '2'
    Samprate1: samp_rate
    Sps1: Sps
    Title: '"Eye Diagramm"'
    Ymax: '2'
    Ymin: '-2'
    gui_hint: menu@0:1,0,1,2
  states: {}
- name: b_PSD_c_0
  id: b_PSD_c
  parameters:
    Ensayos: '1000000'
    Fc: '0'
    N: '1024'
    Ymax: '6e-6'
    gui_hint: menu@1:3,0,1,1
    samp_rate_audio: samp_rate
  states: {}
- name: b_upconverter_cf_0
  id: b_upconverter_cf
  parameters:
    Fc: Rs*2
    samp_rate: '44000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Retardo_Timing
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: Retardo_bits
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/Sps
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (2*math.pi)/M
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: BpS
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpacked_to_packed_xx_0_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: BpS
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: constelacion.base()
    fmax: '0.250'
    fmin: '-0.250'
    loop_bw: 2*math.pi/1000.0
    showports: 'True'
  states: {}
- name: e_VCO_fase_fc_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  \n    \"\"\"Done by Homero Ortega Boada. Es un VCO dos entradas: \nin0 para manipular la fase, in1 para manipular la \nmagnitud. En el fondo es el equivalente a un generador\nde una senal exponencial compleja. Sobre la configuracion:\ncada valor de la senal en in0 es interpretada como la fase\ndeseada en radianes. cada valor de in0, es la magnitud deseada\"\"\"\n\n    def __init__(self): \n        gr.sync_block.__init__(self,\n            name='e_VCO_fase_fc',\n            in_sig=[np.float32, np.float32],\n            out_sig=[np.complex64]\n        )\n    def work(self, input_items, output_items):\n        in0=input_items[0]\n        in1=input_items[1]\n        out0=output_items[0]\n        out0[:] = in1*np.exp(1.j*in0)\n        return len(out0)\n"
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Sps: Sps
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):  # other base classes are basic_block, decim_block, interp_block
          """Este bloque realiza un diezmado asi: cada Sps muestras solo pasa una"""

          def __init__(self, Sps=8):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.decim_block.__init__(
                  self,
                  name='e_diezmador_cc',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64], decim = Sps
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.Sps = Sps

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              in0 = input_items[0]
              out = output_items[0]
              out[:] = in0[::self.Sps]
              return len(output_items[0])
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import gr,digital
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: h
    type: ccc
  states: {}
- name: menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,2
    label0: Timing
    label1: T0 versus R0
    label2: T1 versus R1
    label3: T2 versus R2
    label4: T3 versus R3
    label5: RF
    num_tabs: '6'
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: PCM
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: M-PAM
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: M-PSK
  states: {}
- name: note_0_0_0_0_0
  id: note
  parameters:
    note: Adaptacion
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: menu@1:1,0,1,1
    marker1: '-1'
    marker2: '-1'
    nconnections: '2'
    size: '1024'
    style1: '1'
    style2: '1'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: menu@2:1,0,1,1
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: menu@0:2,0,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: menu@0:2,1,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color2: ("black", "red")
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: menu@5:1,0,1,1
    label1: Envolvente Compleja
    label2: Señal Pasobandas
    name: '"Valor RMS"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@3:1,0,1,1
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: '1024'
    srate: Rs
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@4:1,0,1,1
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: '1024'
    srate: Rs
    stemplot: 'True'
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@1:2,0,1,1
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@5:0,0,1,1
    label1: Senal RF
    label2: EC (Re)
    label3: EC(Im)
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
    width1: '3'
    width2: '3'
    width3: '3'
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: T3
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: T2
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: T1
  states: {}
- name: virtual_sink_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R0
  states: {}
- name: virtual_sink_0_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R1
  states: {}
- name: virtual_sink_0_0_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R0a
  states: {}
- name: virtual_sink_0_0_0_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: R0b
  states: {}
- name: virtual_sink_0_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: T0
  states: {}
- name: virtual_sink_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R2
  states: {}
- name: virtual_sink_0_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: R3
  states: {}
- name: vso_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: T0
  states: {}
- name: vso_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: T1
  states: {}
- name: vso_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: T2
  states: {}
- name: vso_0_1_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: T3
  states: {}
- name: vso_0_1_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: T0
  states: {}
- name: vso_0_1_0_0_1
  id: virtual_source
  parameters:
    stream_id: R1
  states: {}
- name: vso_0_1_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: R2
  states: {}
- name: vso_0_1_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: R3
  states: {}
- name: vso_0_1_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: R0a
  states: {}
- name: vso_0_1_0_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: R1
  states: {}
- name: vso_0_1_0_0_1_1_1
  id: virtual_source
  parameters:
    stream_id: R0a
  states: {}
- name: vso_0_1_0_0_1_1_2
  id: virtual_source
  parameters:
    stream_id: T0
  states: {}
- name: vso_0_1_0_0_1_1_2_0
  id: virtual_source
  parameters:
    stream_id: T0
  states: {}
- name: vso_0_1_0_0_2
  id: virtual_source
  parameters:
    stream_id: R0b
  states: {}
- name: wform
  id: epy_module
  parameters:
    source_code: |
      import math
      import numpy
      #######################################################
      ##        Hecho por Homero Ortega Boada              ##
      ##        comdiguis@saber.uis.edu.co                 ##
      ##     Universidad Industrial de Santander           ##
      #######################################################

      #######################################################
      ##               Forma rectangular                   ##
      #######################################################                       
      def rect(Sps):
          return Sps*[1.,]

      #######################################################
      ##               Forma de Nyquist                    ##
      #######################################################                       
      def nyq(Sps,ntaps):
          n=numpy.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)
          h=numpy.sinc(n/Sps)
      #    return h/numpy.amax(h)
          return h
      #######################################################
      ##               Forma Coseno Alzado                 ##
      #######################################################                       
      def rcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if abs(k)==Sps/(2.*beta):
                      h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.
                  else:
                      h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
          Amp=numpy.amax(h)
          return h/Amp
      #######################################################
      ##            Forma Raiz de Coseno Alzado            ##
      #######################################################                       

      def rrcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              beta4=4.*beta
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if k==0:
                      h[n]=1+beta*(4./math.pi-1.)
                  elif abs(k)==Sps/beta4:
                      ha=(1.+2./math.pi)*math.sin(math.pi/beta4)
                      hb=(1.-2./math.pi)*math.cos(math.pi/beta4)
                      h[n]=(ha+hb)*beta/math.sqrt(2.)
                  else:
                      ks=k/Sps
                      kspi=math.pi*ks
                      Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))
                      Den=kspi*(1.-(beta4*ks)**2)
                      h[n]=Num/Den                
          Amp=numpy.amax(h)
          return h/Amp
  states: {}

connections:
- [analog_const_source_x_0_0_0, '0', e_VCO_fase_fc_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_random_source_x_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0_0, '0']
- [b_upconverter_cf_0, '0', blocks_rms_xx_0_0, '0']
- [b_upconverter_cf_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_add_xx_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0_0_0_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_char_to_float_0_1, '0', blocks_delay_1, '0']
- [blocks_char_to_float_0_2, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_1, '2']
- [blocks_delay_0, '0', epy_block_0, '0']
- [blocks_delay_0, '0', virtual_sink_0_0_0_0_0_0_1, '0']
- [blocks_delay_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_0_0_0_0_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', e_VCO_fase_fc_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', blocks_char_to_float_0_2, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_rms_xx_0_0, '0', qtgui_number_sink_0, '1']
- [blocks_throttle_0, '0', blocks_add_xx_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', blocks_null_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0_0_0_0_1_0, '0']
- [blocks_unpacked_to_packed_xx_0_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_unpacked_to_packed_xx_0_1, '0']
- [digital_constellation_receiver_cb_0, '0', virtual_sink_0_0_0_0_1, '0']
- [e_VCO_fase_fc_0, '0', interp_fir_filter_xxx_0, '0']
- [e_VCO_fase_fc_0, '0', virtual_sink_0_0_0_0_0, '0']
- [epy_block_0, '0', digital_constellation_receiver_cb_0, '0']
- [epy_block_0, '0', virtual_sink_0_0_0_0_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0_0_0_0_1, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [vso_0_1_0_0_0, '0', qtgui_const_sink_x_0, '1']
- [vso_0_1_0_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [vso_0_1_0_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [vso_0_1_0_0_0_0_0, '0', blocks_char_to_float_0, '0']
- [vso_0_1_0_0_0_0_0_0, '0', blocks_char_to_float_0_1, '0']
- [vso_0_1_0_0_0_2, '0', blocks_rms_xx_0, '0']
- [vso_0_1_0_0_1, '0', qtgui_const_sink_x_0_0, '1']
- [vso_0_1_0_0_1_0, '0', blocks_char_to_float_0_0, '0']
- [vso_0_1_0_0_1_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [vso_0_1_0_0_1_1, '0', qtgui_const_sink_x_0_0_0, '0']
- [vso_0_1_0_0_1_1_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [vso_0_1_0_0_1_1_1, '0', b_Eye_Diagram_simple_c_0, '0']
- [vso_0_1_0_0_1_1_2, '0', b_upconverter_cf_0, '0']
- [vso_0_1_0_0_1_1_2_0, '0', blocks_complex_to_float_0, '0']
- [vso_0_1_0_0_2, '0', b_PSD_c_0, '0']
- [vso_0_1_0_0_2, '0', qtgui_const_sink_x_0, '0']
- [vso_0_1_0_0_2, '0', qtgui_time_sink_x_0_1, '1']

metadata:
  file_format: 1
