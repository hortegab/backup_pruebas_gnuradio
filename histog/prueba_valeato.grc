<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>b_v_aleatoria_scope_f</key>
<param><key>id</key><value>b_v_aleatoria_scope_f_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>N_frec</key><value>2014</value></param>
<param><key>N_time</key><value>2014</value></param>
<param><key>V_p</key><value>5</value></param>
</block>
<block>
<key>b_v_aleatoria_scope_pdf_cdf_f</key>
<param><key>id</key><value>b_v_aleatoria_scope_pdf_cdf_f_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>N_frec</key><value>2014</value></param>
<param><key>N_time</key><value>2014</value></param>
<param><key>V_p</key><value>5.</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>b_v_aleatoria_scope_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>b_v_aleatoria_scope_pdf_cdf_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
