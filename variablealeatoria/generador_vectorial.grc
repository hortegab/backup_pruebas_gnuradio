<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>samp_rate/Sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1953125</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>value</key><value>11000</value></param>
</block>
<block>
<key>E3TRadio_unipolar_to_bipolar_ff</key>
<param><key>id</key><value>E3TRadio_unipolar_to_bipolar_ff_0</value></param>
<param><key>Amp</key><value>1.</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Menu</value></param>
<param><key>gui_hint</key><value>1,0,1,4</value></param>
<param><key>label0</key><value>banary random signal</value></param>
<param><key>label1</key><value>sinc wave form random signal</value></param>
<param><key>label2</key><value>saw random signal</value></param>
<param><key>label3</key><value>gaussian white noise</value></param>
<param><key>label4</key><value>voice noise</value></param>
<param><key>num_tabs</key><value>5</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000000</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
</block>
<block>
<key>b_v_aleatoria_scope_f</key>
<param><key>id</key><value>b_v_aleatoria_scope_f_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>Menu@0:0,0,1,1</value></param>
<param><key>N_frec</key><value>1024</value></param>
<param><key>N_time</key><value>20*Sps</value></param>
<param><key>V_p</key><value>1.5</value></param>
</block>
<block>
<key>b_v_aleatoria_scope_f</key>
<param><key>id</key><value>b_v_aleatoria_scope_f_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>Menu@1:0,0,1,1</value></param>
<param><key>N_frec</key><value>1024</value></param>
<param><key>N_time</key><value>20*Sps</value></param>
<param><key>V_p</key><value>1.5</value></param>
</block>
<block>
<key>b_v_aleatoria_scope_f</key>
<param><key>id</key><value>b_v_aleatoria_scope_f_0_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>Menu@2:0,0,1,1</value></param>
<param><key>N_frec</key><value>1024</value></param>
<param><key>N_time</key><value>20*Sps</value></param>
<param><key>V_p</key><value>1.5</value></param>
</block>
<block>
<key>b_v_aleatoria_scope_f</key>
<param><key>id</key><value>b_v_aleatoria_scope_f_0_0_1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>Menu@3:0,0,1,1</value></param>
<param><key>N_frec</key><value>1024</value></param>
<param><key>N_time</key><value>20*Sps</value></param>
<param><key>V_p</key><value>3.</value></param>
</block>
<block>
<key>b_v_aleatoria_scope_f</key>
<param><key>id</key><value>b_v_aleatoria_scope_f_0_0_2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>Menu@4:0,0,1,1</value></param>
<param><key>N_frec</key><value>1024</value></param>
<param><key>N_time</key><value>20*Sps</value></param>
<param><key>V_p</key><value>1.5</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/media/uis-e3t/DATADRIVE1/MisGitHub/comdig2.Lab2.4/bush-clinton_debate_waffle.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>formas</value></param>
<param><key>source_code</key><value>import math
import numpy as np
# senal en forma de ventana
def ventana(Sps):
    return Sps*[1.,]
##  Forma sinc 
def sinc(Sps,ntaps):
    n=np.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)
    h=np.sinc(n/Sps)
#    return h/numpy.amax(h)
    return h
# forma diente se sierra
def saw(Sps):
    return np.linspace(0,Sps-1,Sps)	


</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>Sps</value></param>
<param><key>taps</key><value>formas.sinc(Sps,ntaps)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>interp</key><value>Sps</value></param>
<param><key>taps</key><value>formas.ventana(Sps)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_1</value></param>
<param><key>interp</key><value>Sps</value></param>
<param><key>taps</key><value>formas.saw(Sps)/Sps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>s0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>s1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>s2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0</value></param>
<param><key>stream_id</key><value>s3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>s4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>s0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>s1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0</value></param>
<param><key>stream_id</key><value>s2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_1</value></param>
<param><key>stream_id</key><value>s3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_2</value></param>
<param><key>stream_id</key><value>s4</value></param>
</block>
<connection><source_block_id>E3TRadio_unipolar_to_bipolar_ff_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_unipolar_to_bipolar_ff_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_unipolar_to_bipolar_ff_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>E3TRadio_unipolar_to_bipolar_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_1</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>b_v_aleatoria_scope_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>b_v_aleatoria_scope_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>b_v_aleatoria_scope_f_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_1</source_block_id><sink_block_id>b_v_aleatoria_scope_f_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_2</source_block_id><sink_block_id>b_v_aleatoria_scope_f_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
