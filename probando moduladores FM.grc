<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ac</value></param>
<param><key>value</key><value>1.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Am</value></param>
<param><key>value</key><value>1.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>2*DeltaF3+2*fm</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DeltaF</value></param>
<param><key>value</key><value>beta*fm</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kf</value></param>
<param><key>value</key><value>DeltaF/Am</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>beta</value></param>
<param><key>value</key><value>5.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm</value></param>
<param><key>value</key><value>1000.</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>64000</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>Accum_all_ff</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Hecho por Homoero Ortega. Es un acumulador puro, va acumulando cada muestra entrante mientras entrega lo que lleva acumulado hasta el momento. Puede convertirse en un integrador si la salida se divide en samp_rate, donde samp_rate es la frecuencia de muestreo de la senal, pero pero eso se haria por fuera de este bloque"""

    def __init__(self):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='Accum_all_ff',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
	self.memory=0.
    def work(self, input_items, output_items):
        """El acumulador"""
	in0=input_items[0]
	out0=output_items[0]
        L=len(in0)
	out0[:]=(self.memory+np.cumsum(in0))
	self.memory=out0[L-1]
        return len(out0)
</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>Am</value></param>
<param><key>freq</key><value>fm</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>b_PSD_c</key>
<param><key>id</key><value>b_PSD_c_0</value></param>
<param><key>Fc</key><value>0</value></param>
<param><key>samp_rate_audio</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>'beta=5'</value></param>
<param><key>Ymax</key><value>0.0002</value></param>
</block>
<block>
<key>b_PSD_c</key>
<param><key>id</key><value>b_PSD_c_0_0</value></param>
<param><key>Fc</key><value>0</value></param>
<param><key>samp_rate_audio</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>'e_VCO_fase'</value></param>
<param><key>Ymax</key><value>0.0002</value></param>
</block>
<block>
<key>b_PSD_c</key>
<param><key>id</key><value>b_PSD_c_0_0_0</value></param>
<param><key>Fc</key><value>0</value></param>
<param><key>samp_rate_audio</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>'Integrate+e_VCO_frec'</value></param>
<param><key>Ymax</key><value>0.0002</value></param>
</block>
<block>
<key>b_PSD_c</key>
<param><key>id</key><value>b_PSD_c_0_0_0_0</value></param>
<param><key>Fc</key><value>0</value></param>
<param><key>samp_rate_audio</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>'Accum_all+e_VCO_fase'</value></param>
<param><key>Ymax</key><value>0.0002</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>Kf</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_1</value></param>
<param><key>const</key><value>Kf/100000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_1_0</value></param>
<param><key>const</key><value>2*math.pi*Kf/samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_1_0_0</value></param>
<param><key>const</key><value>2*math.pi*Kf/samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_0_0</value></param>
<param><key>amplitude</key><value>Ac</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value>2*math.pi</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_VCO_fase_fc</value></param>
<param><key>Ac</key><value>Ac</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  
    """Done by Homero Ortega Boada"""

    def __init__(self, Ac=1.):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='e_VCO_fase_fc',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.complex64]
        )
        self.Ac = Ac
    def work(self, input_items, output_items):
	in0=input_items[0]
	out0=output_items[0]
        L=len(in0)
#	theta=2.*np.pi*in0
	theta=in0
	out0[:] = self.Ac*np.exp(1.j*theta)
	return len(out0)
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_VCO_fase_fc_0</value></param>
<param><key>Ac</key><value>Ac</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  
    """Done by Homero Ortega Boada"""

    def __init__(self, Ac=1.):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='e_VCO_fase_fc',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.complex64]
        )
        self.Ac = Ac
    def work(self, input_items, output_items):
	in0=input_items[0]
	out0=output_items[0]
        L=len(in0)
#	theta=2.*np.pi*in0
	theta=in0
	out0[:] = self.Ac*np.exp(1.j*theta)
	return len(out0)
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>Ac</key><value>1.0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  
    """Done by Homero Ortega Boada"""

    def __init__(self, samp_rate=200000., Ac=1.):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='e_VCO_frec_fc',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.complex64]
        )
        self.samp_rate = float(samp_rate)
        self.Ac = Ac
	self.last_t=0.

    def work(self, input_items, output_items):
	in0=input_items[0]
	out0=output_items[0]
        L=len(in0)
	t=np.arange(L)/self.samp_rate+self.last_t
	theta=2.*np.pi*in0*t
	out0[:] = self.Ac*np.exp(1.j*theta)
	self.last_t += L/self.samp_rate
	return len(out0)
</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>original</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>integrada</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs_0_0</value></param>
<param><key>stream_id</key><value>P3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>P0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>P0a</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs_0_0_1</value></param>
<param><key>stream_id</key><value>P4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs_0_0_1_0</value></param>
<param><key>stream_id</key><value>P5</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs_0_0_2</value></param>
<param><key>stream_id</key><value>P2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso_0_0</value></param>
<param><key>stream_id</key><value>P3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso_0_0_0</value></param>
<param><key>stream_id</key><value>P4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso_0_0_0_0</value></param>
<param><key>stream_id</key><value>P2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>P0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>P0a</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso_0_0_0_0_1</value></param>
<param><key>stream_id</key><value>P5</value></param>
</block>
<connection><source_block_id>Accum_all_ff</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Accum_all_ff</source_block_id><sink_block_id>vs_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>Accum_all_ff</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_integrate_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>vs_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_vco_c_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_1</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_1_0</source_block_id><sink_block_id>e_VCO_fase_fc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_1_0_0</source_block_id><sink_block_id>e_VCO_fase_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_0_0</source_block_id><sink_block_id>vs_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_VCO_fase_fc</source_block_id><sink_block_id>vs_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_VCO_fase_fc_0</source_block_id><sink_block_id>vs_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>vs_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso_0_0</source_block_id><sink_block_id>b_PSD_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso_0_0_0</source_block_id><sink_block_id>b_PSD_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso_0_0_0_0</source_block_id><sink_block_id>b_PSD_c_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso_0_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso_0_0_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vso_0_0_0_0_1</source_block_id><sink_block_id>b_PSD_c_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
