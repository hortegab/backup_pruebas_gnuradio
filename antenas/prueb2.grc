options:
  parameters:
    generate_options: qt_gui
    id: prueb2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Dz
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: N
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Resol_angular_gr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: distancias
  id: variable
  parameters:
    value: Dz*np.array(range(N))
  states: {}
- name: fases
  id: variable
  parameters:
    value: '-2*np.pi*distancias*np.cos(theta_i_gr*np.pi/180)'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: theta_i_gr
  id: variable_qtgui_range
  parameters:
    label: theta_i_gr
    start: '0'
    step: Resol_angular_gr
    stop: '360'
    value: '90'
  states: {}
- name: w
  id: variable
  parameters:
    value: '[1,1,1,1]'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: w[0]*np.exp(1j*fases[0])
    type: complex
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: w[1]*np.exp(1j*fases[1])
    type: complex
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: w[3]*np.exp(1j*fases[3])
    type: complex
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: w[2]*np.exp(1j*fases[2])
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: N
    min: '-N'
    name: '"Campo E"'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_const_source_x_0_0, '0', blocks_add_xx_0, '1']
- [analog_const_source_x_0_0_0, '0', blocks_add_xx_0, '3']
- [analog_const_source_x_0_1, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
