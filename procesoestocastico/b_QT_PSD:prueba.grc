<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>b_PSD_prueba</value></param>
<param><key>author</key><value>Homero Ortega</value></param>
<param><key>category</key><value>borrar</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
<param><key>title</key><value>b_PSD_prueba</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Amp</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Amplitud</value></param>
<param><key>value</key><value>1.</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Ensayos</value></param>
<param><key>label</key><value>N_ensayos</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N</value></param>
<param><key>label</key><value>N_FFT</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Titulo</value></param>
<param><key>label</key><value>Titulo</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'espectro'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Ymax</value></param>
<param><key>label</key><value>Ymax</value></param>
<param><key>value</key><value>1.</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>numpy.full(N,1./(Ensayos*N))</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>N</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """calculate the mean of a staocastic process that comes as a signal. it is considered that every new frame of N samples is a new sample function of the process"""

    def __init__(self, N=1024, Nensayos=1000): 


        gr.sync_block.__init__(self, name='e_stoc_proc_mean_ff', in_sig=[(np.float32, N)],
            out_sig=[(np.float32, N)]
        )
        self.N = N
        self.Nensayos = Nensayos
        self.med=np.empty(N,dtype=np.float32)
#        self.med=np.zeros(N)
        self.count=np.uint64=0

    def work(self, input_items, output_items):
        in0 = input_items[0]
        L=in0.shape
        out0=output_items[0]
        if self.count &lt; self.Nensayos:
            self.count += L[0]	
        self.med = self.med*(self.count-L[0])/self.count+in0.mean(0)*L[0]/self.count
#        self.med = self.med*(self.count-1)/self.count+in0/self.count
        out0[:]=self.med
        return len(out0)
</value></param>
<param><key>N</key><value>N</value></param>
<param><key>Nensayos</key><value>10000</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>N</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>label1</key><value>.</value></param>
<param><key>width1</key><value>4</value></param>
<param><key>name</key><value>Titulo</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>N</value></param>
<param><key>x_axis_label</key><value>"Frecuencia"</value></param>
<param><key>x_start</key><value>-samp_rate_audio/2</value></param>
<param><key>x_step</key><value>(samp_rate_audio-1)/N</value></param>
<param><key>x_units</key><value>"Hz"</value></param>
<param><key>ymax</key><value>Ymax</value></param>
<param><key>ymin</key><value>0.</value></param>
<param><key>y_axis_label</key><value>"Amplitud (Watt/Hz)"</value></param>
<param><key>y_units</key><value>"Watt/Hz"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>label</key><value>Fmuestreo</value></param>
<param><key>value</key><value>22000</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
